PACKAGECONFIG_append = " accessibility fontconfig gles2 linuxfb tslib"

